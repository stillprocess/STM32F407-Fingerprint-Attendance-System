# Keil uVision project project.uvprojx, settings and files
target project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM;..\CMSIS;..\DEVICE_LIB\inc;..\USER;..\FreeRTOS_INCLUDE;..\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s
    ../SYSTEM/: system_stm32f4xx.c
  group DEVICE_LIB
    ../DEVICE_LIB/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group FreeRTOS_Portable
    ../FreeRTOS_Portable/: port.c portmacro.h
  group FreeRTOS_SOURCE
    ../FreeRTOS_SOURCE/: list.c queue.c tasks.c heap_4.c croutine.c event_groups.c timers.c
  group USER
    ./: FreeRTOSConfig.h main.c app_keyboard.c app_keyboard.h app_servo.c app_servo.h app_oled.c app_oled.h app_fingerprint.c app_fingerprint.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group HARDWARE
    ../HARDWARE/: delay.c delay.h spi1.c spi1.h RTC.c uart.c uart.h beep.c beep.h oled.c oled.h w25q128.c RTC.h w25q128.h servo.c servo.h sha256.c sha256.h keyboard.c keyboard.h FPM383F.c FPM383F.h key.c key.h
